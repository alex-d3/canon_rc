<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\msp430g2231_spi.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\msp430g2231_spi.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\msprf24.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\msprf24.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nrf24l01.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\nrf24l01_userconfig.h</name>
  </file>
</project>


